MOV 50H, #03H
MOV 51H, #80H
MOV 52H, #40H
MOV 53H, #00H
MOV 54H, #95H


MOV R0,#50H
MOV R5,#5H
MOV R2,#30H   ;POS
MOV R3,#60H	   ; NEG
MOV R4,#15H		;ZER

LOOP: MOV A,@R0
	  JB ACC.7, NEG1
	  CJNE A, #00H, POS1
	  MOV B, R4
	  MOV R1, B
	  MOV @R1, A
	  INC R4
	  SJMP FINAL
	
POS1:
    MOV B, R2
	MOV R1, B
	MOV @R1, A
	INC R2
	SJMP FINAL
	
NEG1:
	MOV B, R3
	MOV R1, B
	MOV @R1, A
	INC R3

FINAL: 
	INC R0
	DJNZ R5, LOOP
	END
	  