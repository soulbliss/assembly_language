# Keil uVision project progect1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: progect1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lex2.asm lex3.asm lex4.asm LEX5.ASM LSP3.ASM ex1_3_real.asm lsp5.asm ex2_1.asm ex_2_2.asm ex2_3.asm ex_2_4.asm
